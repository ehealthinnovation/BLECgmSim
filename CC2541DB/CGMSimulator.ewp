# IAR project CGMSimulator.ewp, settings and files
configuration CC2541DK-MINI Keyfob Slave (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=TRUE; CC2540_MINIDK; DC_DC_P0_7
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: C:\Texas Instruments\BLE-CC254x-1.4.0\Projects\ble\common; C:\Texas Instruments\BLE-CC254x-1.4.0\Projects\ble\include; C:\Texas Instruments\BLE-CC254x-1.4.0\Components\hal\include; C:\Texas Instruments\BLE-CC254x-1.4.0\Components\hal\target\CC2540EB; C:\Texas Instruments\BLE-CC254x-1.4.0\Components\osal\include; C:\Texas Instruments\BLE-CC254x-1.4.0\Components\services\saddr; C:\Texas Instruments\BLE-CC254x-1.4.0\Components\ble\include; C:\Texas Instruments\BLE-CC254x-1.4.0\Components\ble\controller\phy; C:\Texas Instruments\BLE-CC254x-1.4.0\Components\ble\controller\include; C:\Texas Instruments\BLE-CC254x-1.4.0\Components\ble\hci; C:\Texas Instruments\BLE-CC254x-1.4.0\Components\ble\host; C:\Texas Instruments\BLE-CC254x-1.4.0\Projects\ble\common\cc2540; C:\Texas Instruments\BLE-CC254x-1.4.0\Projects\ble\common\npi\npi_np; C:\Texas Instruments\BLE-CC254x-1.4.0\Projects\ble\Profiles\Roles; C:\Texas Instruments\BLE-CC254x-1.4.0\Projects\ble\Profiles\HIDDev; ..\Profiles\DevInfo; ..\Profiles\CGM; ..\Profiles\Batt
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: C:\Texas Instruments\BLE-CC254x-1.4.0\Projects\ble\common\cc2540\ti_51ew_cc2540b.xcl
  group APP
    ../Source/: cgm.c cgm.h Cgm_Main.c cgmSimData.c OSAL_Cgm.c
  group HAL/Common
    ../../Texas Instruments/BLE-CC254x-1.4.0/Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../Texas Instruments/BLE-CC254x-1.4.0/Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../Texas Instruments/BLE-CC254x-1.4.0/Components/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    ../../Texas Instruments/BLE-CC254x-1.4.0/Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../Texas Instruments/BLE-CC254x-1.4.0/Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../Texas Instruments/BLE-CC254x-1.4.0/Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../Texas Instruments/BLE-CC254x-1.4.0/Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../Texas Instruments/BLE-CC254x-1.4.0/Components/ble/host/: linkdb.h
    ../../Texas Instruments/BLE-CC254x-1.4.0/Components/ble/controller/include/: ll.h phy.h
    ../../common/npi/npi_np/: npi.h
  group LIB
    ../../Texas Instruments/BLE-CC254x-1.4.0/Projects/ble/Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../Texas Instruments/BLE-CC254x-1.4.0/Projects/ble/Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../Texas Instruments/BLE-CC254x-1.4.0/Projects/ble/common/npi/npi_np/: npi.c
    ../../common/npi/npi_np/: npi_spi.c npi_uart.c
  group OSAL
    ../../Texas Instruments/BLE-CC254x-1.4.0/Components/ble/include/: bcomdef.h
    ../../Texas Instruments/BLE-CC254x-1.4.0/Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../Texas Instruments/BLE-CC254x-1.4.0/Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../Profiles/Batt/: battservice.c battservice.h
    ../Profiles/CGM/: cgmservice.c cgmservice.h
    ../Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../Texas Instruments/BLE-CC254x-1.4.0/Projects/ble/Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    ../../Texas Instruments/BLE-CC254x-1.4.0/Projects/ble/Include/: gapgattserver.h gattservapp.h
    ../../Texas Instruments/BLE-CC254x-1.4.0/Components/ble/host/: gatt_uuid.c
  group TOOLS
    ../../Texas Instruments/BLE-CC254x-1.4.0/Projects/ble/config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../Texas Instruments/BLE-CC254x-1.4.0/Projects/ble/common/cc2540/: OnBoard.c OnBoard.h
